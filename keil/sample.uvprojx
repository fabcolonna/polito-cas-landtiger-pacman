# Keil uVision project sample.uvprojx, settings and files
target LandTiger_LPC1768 (release) (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample_BUTTON_DE-BOUNCING
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: .\Source\button_EXINT;.\Source\CMSIS_core;.\Source\led;.\Source\RIT;.\Source
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group PacMan
    ./Source/Program/: main.c
    ./Source/Program/PacMan/: pacman.c pacman.h
  group CMSIS
    ./Source/CMSIS_core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h mpu_armv7.h
  group RIT
    ./Source/Libs/RIT/: rit.c rit.h rit_job.c rit_types.h
  group LED
    ./Source/Libs/LED/: led.c led.h led_types.h
  group Timer
    ./Source/Libs/Timer/: timer.c timer.h timer_types.h timer_irq.c
  group Power
    ./Source/Libs/Power/: power.c power.h power_types.h
  group Utils
    ./Source/Libs/Utils/: includes.h utils.h
  group Joystick
    ./Source/Libs/Joystick/: joystick.c joystick.h joystick_types.h
  group System
    ./Source/System/: startup_LPC17xx.s system_LPC17xx.c
  group ADC-PM
    ./Source/Libs/ADC-PM/: adc_pm.c adc_pm.h adc_pm_irq.c adc_pm_types.h
  group DAC
    ./Source/Libs/DAC/: dac.c dac.h dac_dma.c dac_types.h
  group GLCD
    ./Source/Libs/GLCD/: glcd.c glcd.h glcd_text_utils.c glcd_types.h glcd_utils.h
  group Buttons
    ./Source/Libs/Button/: button.c button.h button_irq.c button_types.h
  group TouchPanel
    ./Source/Libs/TouchPanel/: touch.c touch.h
target SW_Debug (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: cas-base-proj
  c flags: Optim=1 v6Lang=5 v6LangP=3
  c define: SIMULATOR
  c include: .\Source\Libs\Button;.\Source\CMSIS_core;.\Source;.\Source\Libs\RIT;.\Source\Libs\Timer;.\Source\Libs\LED;.\Source\Libs\Power;.\Source\Libs\Utils;.\Source\Program;.\Source\Startup;.\Source\Libs\SysTick;.\Source\Libs\Utils\DynamicArray;.\Source\Libs\Joystick;.\Source\Libs\ADC-PM;.\Source\Libs\DAC;.\Source\Libs\GLCD;.\Source\Program\Sprites;.\Source\Libs\TouchPanel;.\Source\Program\PacMan;.\Source\Program\PacMan\Assets
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 6.1.0, Device:GPDMA 1.4.0
