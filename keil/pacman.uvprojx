# Keil uVision project pacman.uvprojx, settings and files
target prog-dev (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: program-dev
  c flags: Optim=5 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\Source;.\Source\Program;.\Source\Program\Assets\Fonts;.\Source\Program\Assets\Images;.\Source\System;.\Libs\Peripherals\Include
  asm include: .\Source\button_EXINT;.\Source\CMSIS_core;.\Source\led;.\Source\RIT;.\Source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: .\Libs\Peripherals\peripherals.lib
  group System
    ./Source/System/: startup_LPC17xx.s system_LPC17xx.c system.h
  group Program
    ./Source/Program/: main.c
  group PacMan
    ./Source/Program/PacMan/: pacman.c pacman.h pacman_types.h
target prog-sim (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: project-sim
  c flags: Optim=5 v6Lang=5 v6LangP=3 wLevel=2
  c define: SIMULATOR
  c include: .\Source;.\Source\Program;.\Source\Program\Assets\Fonts;.\Source\Program\Assets\Images;.\Source\System;.\Libs\Peripherals\Include;.\Source\Program\Pacman
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: .\Libs\Peripherals\peripherals.lib
software components: CMSIS:CORE 6.1.0, Device:GPDMA 1.4.0
